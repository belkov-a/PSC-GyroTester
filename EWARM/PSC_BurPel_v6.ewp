# IAR project PSC_BurPel_v6.ewp, settings and files
configuration PSC_BurPel_v6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F072xB; STM32F072xx
  ICCARM.CCIncludePath2: ; Includes; Drivers; StartUp; Utilities; HAL_Drivers; Graphics; Menu
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: StartUp; FastRTOS
  OBJCOPY.OOCOutputFile: PSC_BurPel_v6.bin
  ILINK.IlinkOutputFile: PSC_BurPel_v6.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
    StartUp/: main.h
  group Graphics
    Graphics/: ILI9341.h ILI9341_StartUp.c TFT_Drawing.c TFT_Fonts.c TFT_String.c
  group HAL_Drivers
    HAL_Drivers/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Menu
    Menu/: Menu.c Menu.h MenuSettings.c ParametersEnum.c ParametersFloat.c ParametersOutput.c Windows.c
  group StartUp
    StartUp/: startup_stm32f072xb.s stm32f0xx_it.c system_stm32f0xx.c
  group Utilities
    Utilities/: 24C_EEPROM.c 24C_EEPROM.h adc.c adc.h Init.c Init.h Power.c Work.c

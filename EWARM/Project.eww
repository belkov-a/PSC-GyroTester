<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PSC_BurPel_v6.ewp</path>
  </project>
  <batchBuild />
</workspace>
